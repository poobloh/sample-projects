# Keil uVision project Template-C.uvproj, settings and files
target STM32F0Discovery (ARM-ADS)
  device: STM32F051R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: Template-C
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group SystemFiles
    ./: startup_stm32f0xx.s system_stm32f0xx.c
  group SourceFiles
    ./: main.c lib.c
